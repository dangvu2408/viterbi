* NGSPICE file created from viterbi_decoder.ext - technology: sky130A

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_4 abstract view
.subckt sky130_fd_sc_hd__and4bb_4 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

.subckt viterbi_decoder VGND VPWR clk data[0] data[10] data[11] data[12] data[13]
+ data[14] data[15] data[1] data[2] data[3] data[4] data[5] data[6] data[7] data[8]
+ data[9] data_out[0] data_out[1] data_out[2] data_out[3] data_out[4] data_out[5]
+ data_out[6] data_out[7] done_flag en rst
XFILLER_54_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1270_ clknet_4_10_0_clk _0282_ _0152_ VGND VGND VPWR VPWR mem1.trellis_diagr\[10\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_14_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0985_ mem1.trace\[2\] net41 mem1.trace\[0\] VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__nor3b_2
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0770_ net38 _0377_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__nor2_1
X_1322_ clknet_4_13_0_clk _0204_ _0038_ VGND VGND VPWR VPWR c1.count\[0\] sky130_fd_sc_hd__dfrtp_1
X_1253_ clknet_4_8_0_clk _0265_ _0135_ VGND VGND VPWR VPWR mem1.trellis_diagr\[29\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1184_ net63 VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
X_0968_ br1.data_rx\[0\] br1.data_rx\[1\] VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__or2_1
XFILLER_32_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0899_ _0469_ _0489_ _0495_ add1.en_add VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_25_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0822_ add1.sum_00\[4\] _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__xor2_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0684_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__inv_2
X_0753_ add1.sum_11\[1\] add1.hamd_4\[1\] VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__nand2_1
X_1236_ clknet_4_7_0_clk _0249_ _0118_ VGND VGND VPWR VPWR add1.sum_10\[2\] sky130_fd_sc_hd__dfrtp_4
X_1305_ clknet_4_12_0_clk _0187_ _0029_ VGND VGND VPWR VPWR mem1.trellis_diagr\[20\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1167_ net64 VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__inv_2
X_1098_ net56 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1021_ mem1.trellis_diagr\[4\]\[0\] _0353_ net33 mem1.trellis_diagr\[1\]\[0\] _0354_
+ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a221o_1
X_0805_ add1.sum_01\[2\] net37 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__and2_1
X_0598_ net165 c1.state\[3\] net17 VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__mux2_1
X_0667_ mem1.count\[2\] _0308_ _0312_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__nor3_2
X_0736_ net109 add1.prv_st_01\[0\] _0359_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__mux2_1
X_1219_ clknet_4_10_0_clk _0004_ _0101_ VGND VGND VPWR VPWR tbck1.select_node\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold74 mem1.trellis_diagr\[29\]\[0\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 mem1.trellis_diagr\[31\]\[0\] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 bck_prv_st_01\[1\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 mem1.trellis_diagr\[15\]\[1\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 mem1.trellis_diagr\[4\]\[0\] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold96 mem1.trellis_diagr\[26\]\[0\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 mem1.trellis_diagr\[24\]\[1\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_16_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1004_ mem1.trellis_diagr\[17\]\[1\] net33 _0556_ mem1.trellis_diagr\[22\]\[1\] VGND
+ VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a22o_1
X_0719_ net44 net163 _0361_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__mux2_1
XFILLER_40_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput20 net20 VGND VGND VPWR VPWR data_out[1] sky130_fd_sc_hd__buf_2
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0984_ mem1.trellis_diagr\[24\]\[0\] net35 _0553_ mem1.trellis_diagr\[31\]\[0\] VGND
+ VGND VPWR VPWR _0554_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_14_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1252_ clknet_4_10_0_clk _0264_ _0134_ VGND VGND VPWR VPWR mem1.trellis_diagr\[16\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1321_ clknet_4_11_0_clk _0203_ VGND VGND VPWR VPWR bck_prv_st_00\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_19_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1183_ net63 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__inv_2
X_0967_ br1.data_rx\[1\] _0338_ net175 VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__and3b_1
X_0898_ _0480_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0821_ add1.sum_00\[3\] add1.sum_00\[2\] _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__and3_1
X_0752_ net77 add1.prv_st_10\[0\] _0360_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__mux2_1
XFILLER_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0683_ mem1.count\[2\] _0310_ _0348_ mem1.count\[3\] VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__or4b_4
X_1166_ net64 VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__inv_2
X_1235_ clknet_4_7_0_clk _0248_ _0117_ VGND VGND VPWR VPWR add1.sum_10\[1\] sky130_fd_sc_hd__dfrtp_2
X_1304_ clknet_4_9_0_clk _0186_ _0028_ VGND VGND VPWR VPWR mem1.trellis_diagr\[20\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1097_ net49 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__inv_2
XFILLER_20_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
X_1020_ mem1.trellis_diagr\[3\]\[0\] _0552_ _0553_ mem1.trellis_diagr\[7\]\[0\] VGND
+ VGND VPWR VPWR _0584_ sky130_fd_sc_hd__a22o_1
XFILLER_46_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0804_ net31 _0410_ _0411_ _0380_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a31o_1
X_0735_ net116 net43 _0359_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__mux2_1
X_0666_ net17 net74 VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__xor2_1
X_0597_ net46 VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__inv_2
XFILLER_52_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1149_ net59 VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__inv_2
XFILLER_37_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1218_ clknet_4_11_0_clk _0003_ _0100_ VGND VGND VPWR VPWR tbck1.select_node\[0\]
+ sky130_fd_sc_hd__dfstp_1
XFILLER_4_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold20 _0226_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 tbck1.sel_bit_out\[1\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 mem1.trellis_diagr\[2\]\[0\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 mem1.trellis_diagr\[12\]\[1\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 mem1.trellis_diagr\[26\]\[1\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 mem1.trellis_diagr\[25\]\[1\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 mem1.trellis_diagr\[12\]\[0\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 mem1.trellis_diagr\[21\]\[1\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1003_ mem1.trellis_diagr\[18\]\[1\] net34 _0552_ mem1.trellis_diagr\[19\]\[1\] VGND
+ VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a22o_1
XFILLER_34_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0718_ net164 add1.prv_st_00\[0\] _0313_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0649_ _0307_ tbck1.select_node\[1\] net173 _0335_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__o31a_1
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput21 net21 VGND VGND VPWR VPWR data_out[2] sky130_fd_sc_hd__buf_2
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0983_ mem1.trace\[2\] net41 net42 VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__and3_2
XFILLER_8_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1320_ clknet_4_11_0_clk _0202_ VGND VGND VPWR VPWR bck_prv_st_00\[0\] sky130_fd_sc_hd__dfxtp_1
X_1182_ net65 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1251_ clknet_4_3_0_clk _0263_ _0133_ VGND VGND VPWR VPWR mem1.trellis_diagr\[16\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_32_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0897_ _0491_ _0492_ _0493_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__a31oi_4
X_0966_ _0337_ _0546_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_4_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0820_ add1.sum_00\[0\] add1.hamd_1\[0\] _0423_ _0421_ VGND VGND VPWR VPWR _0424_
+ sky130_fd_sc_hd__a31o_1
X_0751_ _0360_ net105 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__and2b_1
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0682_ net119 add1.prv_st_10\[0\] _0350_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__mux2_1
X_1303_ clknet_4_9_0_clk _0185_ _0027_ VGND VGND VPWR VPWR mem1.trace\[2\] sky130_fd_sc_hd__dfstp_2
X_1165_ net64 VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__inv_2
X_1234_ clknet_4_5_0_clk _0247_ _0116_ VGND VGND VPWR VPWR add1.sum_10\[0\] sky130_fd_sc_hd__dfrtp_1
X_1096_ net54 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0949_ bck_prv_st_01\[0\] bck_prv_st_01\[1\] VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_30_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0665_ _0341_ net98 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__nor2_1
X_0803_ _0408_ _0409_ _0405_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__a21o_1
XFILLER_6_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0734_ net118 add1.prv_st_01\[0\] _0350_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__mux2_1
X_0596_ tbck1.select_node\[3\] VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__inv_2
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1148_ net59 VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__inv_2
X_1079_ net52 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__inv_2
XFILLER_37_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1217_ clknet_4_4_0_clk net7 _0099_ VGND VGND VPWR VPWR br1.data_reg\[15\] sky130_fd_sc_hd__dfrtp_1
Xhold32 c1.count\[1\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net26 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 tbck1.sel_bit_out\[6\] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 mem1.trellis_diagr\[25\]\[0\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 mem1.trellis_diagr\[30\]\[0\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 mem1.trellis_diagr\[30\]\[1\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 mem1.trellis_diagr\[14\]\[0\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 mem1.trellis_diagr\[20\]\[0\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 mem1.trellis_diagr\[23\]\[0\] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_7_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1002_ net133 _0548_ _0569_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__o21a_1
X_0717_ _0313_ net81 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__and2b_1
X_0648_ net45 tbck1.in_bit VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__or2_1
XFILLER_13_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput22 net22 VGND VGND VPWR VPWR data_out[3] sky130_fd_sc_hd__buf_2
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0982_ mem1.trace\[2\] net41 net42 VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__and3b_4
XFILLER_27_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1181_ net64 VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__inv_2
X_1250_ clknet_4_3_0_clk _0262_ _0132_ VGND VGND VPWR VPWR mem1.trellis_diagr\[17\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_20_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0896_ _0470_ _0477_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nor2_1
X_0965_ br1.data_rx\[0\] br1.data_rx\[1\] VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0681_ _0348_ _0349_ net154 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__o21a_1
X_0750_ add1.prv_st_11\[0\] net130 _0358_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__mux2_1
X_1233_ clknet_4_7_0_clk _0009_ _0115_ VGND VGND VPWR VPWR add1.prv_st_10\[0\] sky130_fd_sc_hd__dfrtp_2
X_1302_ clknet_4_11_0_clk _0184_ _0026_ VGND VGND VPWR VPWR mem1.trace\[1\] sky130_fd_sc_hd__dfstp_1
XFILLER_37_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1164_ net62 VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__inv_2
X_1095_ net54 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__inv_2
X_0948_ _0309_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nor2_1
X_0879_ net37 _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_30_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0802_ _0382_ _0408_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__nand3_1
X_0664_ net17 c1.count\[0\] net97 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__a21oi_1
X_0733_ net140 net43 _0350_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__mux2_1
X_0595_ mem1.count\[1\] VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__inv_2
X_1216_ clknet_4_0_0_clk net6 _0098_ VGND VGND VPWR VPWR br1.data_reg\[14\] sky130_fd_sc_hd__dfrtp_1
X_1078_ net52 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__inv_2
X_1147_ net61 VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_35_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold22 _0232_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold11 mem1.trellis_diagr\[5\]\[0\] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 _0344_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold55 tbck1.sel_bit_out\[5\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 mem1.trellis_diagr\[7\]\[0\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 mem1.trellis_diagr\[6\]\[0\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 mem1.trellis_diagr\[28\]\[0\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 mem1.trellis_diagr\[9\]\[1\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 mem1.trellis_diagr\[13\]\[0\] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1001_ _0549_ _0566_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__or3_1
X_0647_ net94 tbck1.in_bit _0334_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__mux2_1
X_0716_ add1.prv_st_00\[0\] net153 _0361_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__mux2_1
XFILLER_13_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput23 net23 VGND VGND VPWR VPWR data_out[4] sky130_fd_sc_hd__buf_2
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0981_ net41 net42 mem1.trace\[2\] VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__and3b_2
XFILLER_27_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1180_ net65 VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__inv_2
XFILLER_17_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0964_ _0338_ _0545_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__and2_1
XFILLER_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0895_ _0469_ _0480_ _0489_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__or3_1
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0680_ _0348_ _0349_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__nor2_2
XFILLER_49_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1232_ clknet_4_2_0_clk net32 _0114_ VGND VGND VPWR VPWR add1.prv_st_01\[1\] sky130_fd_sc_hd__dfrtp_1
X_1301_ clknet_4_11_0_clk _0183_ _0025_ VGND VGND VPWR VPWR mem1.trace\[0\] sky130_fd_sc_hd__dfstp_1
XTAP_TAPCELL_ROW_47_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1094_ net57 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__inv_2
X_1163_ net58 VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__inv_2
X_0947_ _0307_ bck_prv_st_11\[0\] bck_prv_st_11\[1\] VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__or3b_1
XFILLER_20_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0878_ add1.sum_00\[4\] _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__xor2_1
XFILLER_50_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload0 clknet_4_0_0_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__inv_8
XFILLER_19_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0801_ _0369_ _0377_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nand2_2
X_0663_ _0342_ _0343_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nor2_1
XFILLER_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0594_ net45 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__inv_2
XFILLER_6_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0732_ net131 add1.prv_st_11\[0\] _0350_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__mux2_1
X_1146_ net58 VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__inv_2
X_1215_ clknet_4_4_0_clk net5 _0097_ VGND VGND VPWR VPWR br1.data_reg\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_40_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1077_ net51 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__inv_2
XFILLER_37_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 net22 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 mem1.trellis_diagr\[24\]\[0\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 mem1.trellis_diagr\[23\]\[1\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 mem1.trellis_diagr\[19\]\[0\] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold12 mem1.trellis_diagr\[18\]\[0\] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold89 mem1.trellis_diagr\[20\]\[1\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 mem1.trellis_diagr\[19\]\[1\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 mem1.trellis_diagr\[21\]\[0\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1000_ mem1.trellis_diagr\[16\]\[0\] _0354_ _0553_ mem1.trellis_diagr\[23\]\[0\]
+ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a221o_1
X_0715_ net103 _0361_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__and2_1
X_0646_ _0316_ _0324_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__nor2_1
XFILLER_15_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1129_ net59 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__inv_2
XFILLER_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput24 net24 VGND VGND VPWR VPWR data_out[5] sky130_fd_sc_hd__buf_2
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0629_ tbck1.count\[2\] net39 net40 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__or3_1
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0980_ mem1.trace\[2\] net42 net41 VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nor3b_2
XFILLER_8_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0894_ _0470_ _0477_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nand2_1
X_0963_ _0543_ _0544_ br1.count\[3\] VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1231_ clknet_4_3_0_clk _0008_ _0113_ VGND VGND VPWR VPWR add1.prv_st_01\[0\] sky130_fd_sc_hd__dfrtp_2
X_1162_ net47 VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__inv_2
X_1300_ clknet_4_11_0_clk _0182_ _0024_ VGND VGND VPWR VPWR mem1.trellis_diagr\[0\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_47_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1093_ net55 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__inv_2
X_0877_ add1.sum_00\[3\] add1.sum_00\[2\] _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__nand3_1
XFILLER_9_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0946_ _0307_ net168 _0532_ _0534_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__a211o_1
XFILLER_18_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload1 clknet_4_1_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_21_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0800_ _0382_ _0405_ _0406_ _0403_ _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__a221o_2
X_0731_ net125 net43 _0350_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__mux2_1
X_0662_ net174 _0341_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__nor2_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1214_ clknet_4_0_0_clk net4 _0096_ VGND VGND VPWR VPWR br1.data_reg\[12\] sky130_fd_sc_hd__dfrtp_1
X_1145_ net58 VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__inv_2
XFILLER_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1076_ net51 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__inv_2
XFILLER_20_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0929_ _0405_ _0519_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__and2_1
Xhold57 net23 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 net24 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 net19 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 mem1.trellis_diagr\[1\]\[0\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 mem1.trellis_diagr\[8\]\[1\] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 bck_prv_st_10\[0\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 mem1.trellis_diagr\[5\]\[1\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0645_ _0328_ _0330_ _0333_ net107 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__a22o_1
X_0714_ add1.prv_st_10\[0\] net147 _0361_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__mux2_1
X_1128_ net62 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__inv_2
X_1059_ net50 VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__inv_2
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput25 net25 VGND VGND VPWR VPWR data_out[6] sky130_fd_sc_hd__buf_2
XFILLER_16_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0628_ net39 net40 tbck1.count\[2\] VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__o21ai_1
XFILLER_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold110 br1.data_rx\[0\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_10_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0893_ _0483_ _0487_ _0488_ _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__a211o_1
X_0962_ br1.data_reg\[9\] br1.data_reg\[11\] br1.data_reg\[13\] br1.data_reg\[15\]
+ br1.count\[1\] br1.count\[2\] VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__mux4_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout60 net61 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_4
XFILLER_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1230_ clknet_4_13_0_clk _0246_ _0112_ VGND VGND VPWR VPWR add1.sum_00\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1161_ net47 VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__inv_2
X_1092_ net48 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_47_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0876_ _0422_ _0472_ _0471_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__o21ai_2
X_0945_ bck_prv_st_10\[1\] bck_prv_st_10\[0\] tbck1.select_node\[1\] net45 VGND VGND
+ VPWR VPWR _0534_ sky130_fd_sc_hd__o211a_1
Xclkload2 clknet_4_2_0_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_21_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0661_ net69 _0342_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__xor2_1
XFILLER_6_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0730_ net127 add1.prv_st_01\[0\] net28 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__mux2_1
X_1213_ clknet_4_4_0_clk net3 _0095_ VGND VGND VPWR VPWR br1.data_reg\[11\] sky130_fd_sc_hd__dfrtp_1
X_1075_ net52 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__inv_2
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1144_ net56 VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__inv_2
X_0859_ _0459_ _0460_ add1.sum_10\[2\] net37 VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0928_ _0382_ _0519_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__nor2_1
Xhold36 net21 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 _0229_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 _0230_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 _0225_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 mem1.trellis_diagr\[22\]\[1\] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 bck_prv_st_00\[0\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0644_ tbck1.count\[2\] _0321_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__nand2b_1
X_0713_ net112 _0361_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_27_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1127_ net59 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_11_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1058_ net47 VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__inv_2
Xoutput26 net26 VGND VGND VPWR VPWR data_out[7] sky130_fd_sc_hd__buf_2
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0627_ net39 net40 tbck1.in_bit VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__and3_1
XFILLER_38_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold100 c1.state\[2\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold111 br1.data_rx\[1\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0961_ br1.data_reg\[1\] br1.data_reg\[3\] br1.data_reg\[5\] br1.data_reg\[7\] br1.count\[1\]
+ br1.count\[2\] VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__mux4_1
X_0892_ _0469_ _0489_ _0479_ _0476_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_10_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout61 net18 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_2
Xfanout50 net51 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_4
XFILLER_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1160_ net46 VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__inv_2
X_1091_ net48 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
X_0944_ bck_prv_st_10\[1\] bck_prv_st_10\[0\] VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nor2_1
X_0875_ _0471_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__nand2_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_41_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1289_ clknet_4_8_0_clk _0301_ _0171_ VGND VGND VPWR VPWR mem1.trellis_diagr\[26\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
Xclkload3 clknet_4_3_0_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinvlp_4
XTAP_TAPCELL_ROW_21_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0660_ c1.count\[2\] _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__and2_1
XFILLER_6_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1212_ clknet_4_0_0_clk net2 _0094_ VGND VGND VPWR VPWR br1.data_reg\[10\] sky130_fd_sc_hd__dfrtp_1
X_1074_ net49 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__inv_2
X_1143_ net56 VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__inv_2
X_0927_ add1.sum_11\[4\] _0520_ net32 VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__mux2_1
X_0858_ _0449_ _0457_ net37 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__a21o_1
X_0789_ _0387_ _0395_ _0396_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__nand3_1
Xhold37 _0227_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 mem1.trellis_diagr\[31\]\[1\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 mem1.trellis_diagr\[15\]\[0\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 mem1.trellis_diagr\[10\]\[0\] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 mem1.trellis_diagr\[16\]\[0\] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0643_ tbck1.in_bit net160 _0332_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__mux2_1
X_0712_ _0308_ mem1.count\[0\] _0349_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__or3_4
X_1126_ net48 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__inv_2
XFILLER_33_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1057_ net50 VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__inv_2
XFILLER_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput27 net27 VGND VGND VPWR VPWR done_flag sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_54_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0626_ net40 _0315_ _0317_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ net49 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold101 _0002_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_13_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0609_ tbck1.sel_bit_out\[5\] net89 _0314_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__mux2_1
XFILLER_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0960_ _0338_ _0542_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__and2_1
XFILLER_32_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0891_ add1.sum_01\[2\] _0468_ add1.sum_01\[3\] VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_10_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout51 net52 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_4
Xfanout40 tbck1.count\[0\] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
Xfanout62 net65 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
XFILLER_49_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1090_ net54 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__inv_2
X_0874_ add1.sum_00\[1\] add1.hamd_1\[1\] VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__or2_1
Xclkload10 clknet_4_10_0_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinv_2
X_0943_ bck_prv_st_00\[1\] bck_prv_st_00\[0\] tbck1.select_node\[0\] net45 VGND VGND
+ VPWR VPWR _0532_ sky130_fd_sc_hd__o211a_1
X_1288_ clknet_4_14_0_clk _0300_ _0170_ VGND VGND VPWR VPWR mem1.trellis_diagr\[4\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload4 clknet_4_4_0_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_21_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1142_ net56 VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__inv_2
X_1211_ clknet_4_4_0_clk net16 _0093_ VGND VGND VPWR VPWR br1.data_reg\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1073_ net48 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__inv_2
X_0857_ _0448_ _0457_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__nor2_1
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0926_ _0369_ _0378_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__mux2_1
Xhold38 mem1.trellis_diagr\[6\]\[1\] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 mem1.trellis_diagr\[7\]\[1\] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 mem1.trellis_diagr\[0\]\[1\] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlygate4sd3_1
X_0788_ _0384_ _0386_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nand2_1
XFILLER_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold49 mem1.trellis_diagr\[2\]\[1\] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0711_ net76 add1.prv_st_00\[0\] _0359_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__mux2_1
X_0642_ tbck1.count\[2\] tbck1.count\[0\] _0316_ net39 VGND VGND VPWR VPWR _0332_
+ sky130_fd_sc_hd__or4b_1
X_1125_ net59 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__inv_2
XFILLER_25_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1056_ net47 VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__inv_2
X_0909_ add1.sum_11\[3\] add1.sum_11\[2\] _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__and3_1
XFILLER_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0625_ net39 _0314_ _0317_ _0321_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__a31o_1
XFILLER_53_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1039_ net50 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__inv_2
X_1108_ net55 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__inv_2
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold102 tbck1.select_node\[0\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
X_0608_ net75 net93 _0314_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__mux2_1
XFILLER_37_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0890_ _0484_ _0486_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__and2_1
XFILLER_32_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout52 net53 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_4
Xfanout63 net65 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_2
Xfanout41 mem1.trace\[1\] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_2
XFILLER_29_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0873_ add1.sum_00\[1\] add1.hamd_1\[1\] VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nor2_1
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload11 clknet_4_11_0_clk VGND VGND VPWR VPWR clkload11/X sky130_fd_sc_hd__clkbuf_8
X_0942_ net104 net134 net45 VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_38_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1287_ clknet_4_12_0_clk _0299_ _0169_ VGND VGND VPWR VPWR mem1.trellis_diagr\[4\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
Xclkload5 clknet_4_5_0_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_21_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1072_ net60 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__inv_2
X_1141_ net62 VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__inv_2
X_1210_ clknet_4_0_0_clk net15 _0092_ VGND VGND VPWR VPWR br1.data_reg\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0856_ add1.sum_10\[3\] _0458_ net31 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__mux2_1
X_0787_ _0390_ _0393_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__xnor2_1
X_0925_ _0504_ _0507_ _0517_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a2bb2o_2
Xhold17 mem1.trellis_diagr\[3\]\[1\] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 bck_prv_st_00\[1\] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 net25 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1339_ clknet_4_15_0_clk _0221_ _0055_ VGND VGND VPWR VPWR tbck1.count\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_43_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0641_ _0322_ _0330_ _0331_ net73 VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__a22o_1
X_0710_ _0359_ net111 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__and2b_1
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1124_ net48 VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__inv_2
X_1055_ net50 VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__inv_2
X_0839_ _0428_ _0440_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__nand2_1
X_0908_ add1.sum_11\[0\] add1.hamd_3\[0\] _0389_ _0388_ VGND VGND VPWR VPWR _0502_
+ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_54_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0624_ tbck1.count\[1\] tbck1.count\[0\] _0315_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__and3b_1
XFILLER_53_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1038_ net50 VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ net54 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__inv_2
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0607_ tbck1.sel_bit_out\[7\] net86 _0314_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__mux2_1
Xhold103 tbck1.select_node\[2\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout53 net18 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_2
Xfanout64 net65 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_4
Xfanout31 net32 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_4
Xfanout42 mem1.trace\[0\] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_2
XFILLER_49_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0941_ add1.sum_11\[0\] net32 _0529_ _0530_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__o22a_1
X_0872_ add1.sum_00\[1\] add1.hamd_1\[1\] VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__nand2_1
Xclkload12 clknet_4_12_0_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_38_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1286_ clknet_4_14_0_clk _0298_ _0168_ VGND VGND VPWR VPWR mem1.trellis_diagr\[5\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
Xclkload6 clknet_4_6_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_8
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1071_ net52 VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__inv_2
XFILLER_37_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1140_ net53 VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__inv_2
X_0924_ _0504_ _0507_ _0513_ _0515_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__o2bb2a_1
X_0855_ _0435_ _0454_ _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
X_0786_ _0393_ _0390_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__and2b_1
X_1338_ clknet_4_15_0_clk _0220_ _0054_ VGND VGND VPWR VPWR tbck1.count\[0\] sky130_fd_sc_hd__dfrtp_1
Xhold29 tbck1.sel_bit_out\[0\] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 mem1.trellis_diagr\[8\]\[0\] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1269_ clknet_4_9_0_clk _0281_ _0151_ VGND VGND VPWR VPWR mem1.trellis_diagr\[10\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0640_ net39 net40 _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__nand3_1
XFILLER_2_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1123_ net59 VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__inv_2
X_1054_ net47 VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__inv_2
X_0907_ add1.sum_00\[0\] _0501_ net32 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__mux2_1
X_0838_ _0428_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__and2_1
Xoutput19 net19 VGND VGND VPWR VPWR data_out[0] sky130_fd_sc_hd__buf_2
X_0769_ _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0623_ _0314_ _0318_ _0320_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__and3_1
XFILLER_38_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1106_ net55 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__inv_2
XFILLER_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1037_ net50 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold104 c1.state\[0\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
X_0606_ tbck1.count\[3\] net45 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__nand2_4
XFILLER_26_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout32 add1.en_add VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_4
Xfanout65 net18 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_2
Xfanout43 add1.prv_st_01\[1\] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_2
Xfanout54 net55 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_4
XFILLER_22_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_35_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0940_ _0384_ _0519_ net38 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a21o_1
X_0871_ add1.sum_01\[4\] _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xor2_1
Xclkload13 clknet_4_13_0_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinv_2
XFILLER_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1354_ clknet_4_13_0_clk _0236_ _0070_ VGND VGND VPWR VPWR c1.state\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1285_ clknet_4_12_0_clk _0297_ _0167_ VGND VGND VPWR VPWR mem1.trellis_diagr\[5\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_46_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload7 clknet_4_7_0_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__inv_6
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1070_ net52 VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__inv_2
XFILLER_33_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0854_ _0426_ _0432_ _0455_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__a22o_2
X_0923_ _0508_ _0511_ _0513_ _0515_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0785_ _0371_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__xnor2_1
Xhold19 net20 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dlygate4sd3_1
X_1337_ clknet_4_15_0_clk _0219_ _0053_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_1268_ clknet_4_10_0_clk _0280_ _0150_ VGND VGND VPWR VPWR mem1.trellis_diagr\[11\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_28_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1199_ clknet_4_5_0_clk _0015_ _0081_ VGND VGND VPWR VPWR add1.hamd_2\[1\] sky130_fd_sc_hd__dfrtp_2
XFILLER_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1122_ net48 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__inv_2
XFILLER_33_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1053_ net50 VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__inv_2
X_0906_ _0441_ _0444_ _0495_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__mux2_1
X_0837_ add1.sum_01\[0\] add1.hamd_1\[0\] VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__or2_1
X_0768_ add1.sum_10\[4\] _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__xnor2_2
X_0699_ _0359_ net96 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_54_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0622_ net45 net39 net40 tbck1.count\[2\] VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__a31o_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1105_ net55 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__inv_2
X_1036_ net50 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__inv_2
XFILLER_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold105 mem1.count\[1\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
X_0605_ net106 add1.prv_st_11\[0\] _0313_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__mux2_1
X_1019_ net128 _0548_ _0581_ _0583_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__o22a_1
XFILLER_26_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout44 add1.prv_st_01\[1\] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout55 net58 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_4
XFILLER_49_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0870_ add1.sum_01\[3\] add1.sum_01\[2\] _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_15_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload14 clknet_4_14_0_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__bufinv_16
X_1353_ clknet_4_13_0_clk _0235_ _0069_ VGND VGND VPWR VPWR c1.state\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_38_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1284_ clknet_4_2_0_clk _0296_ _0166_ VGND VGND VPWR VPWR mem1.trellis_diagr\[22\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_46_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload8 clknet_4_8_0_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__clkinv_2
X_0999_ mem1.trellis_diagr\[18\]\[0\] _0550_ _0556_ mem1.trellis_diagr\[22\]\[0\]
+ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a22o_1
XFILLER_49_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0853_ _0426_ _0432_ _0435_ _0453_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__o22a_1
X_0922_ _0509_ _0510_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nor2_1
X_0784_ add1.sum_10\[1\] add1.hamd_4\[1\] VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__xor2_1
X_1198_ clknet_4_4_0_clk _0012_ _0080_ VGND VGND VPWR VPWR br1.data_rx\[1\] sky130_fd_sc_hd__dfrtp_1
Xinput1 data[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_1267_ clknet_4_2_0_clk _0279_ _0149_ VGND VGND VPWR VPWR mem1.trellis_diagr\[11\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1336_ clknet_4_14_0_clk _0218_ _0052_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1121_ net62 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__inv_2
X_1052_ net47 VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__inv_2
XFILLER_33_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0905_ add1.sum_00\[1\] net37 _0499_ _0500_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a22o_1
X_0836_ _0436_ _0437_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__nand2_1
X_0767_ add1.sum_10\[3\] add1.sum_10\[2\] _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__and3_1
X_0698_ mem1.count\[2\] _0308_ mem1.count\[0\] _0311_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__and4_4
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1319_ clknet_4_11_0_clk _0201_ VGND VGND VPWR VPWR bck_prv_st_01\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap30 _0357_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
XFILLER_46_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0621_ tbck1.count\[3\] _0307_ _0319_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a21bo_1
XFILLER_53_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1104_ net54 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
X_1035_ net48 VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__inv_2
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0819_ add1.sum_00\[1\] add1.hamd_2\[1\] VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__xor2_2
XFILLER_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0604_ net113 net44 _0313_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__mux2_1
Xhold106 mem1.trace\[2\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_34_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1018_ mem1.trellis_diagr\[10\]\[1\] net34 _0552_ mem1.trellis_diagr\[11\]\[1\] _0582_
+ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a221o_1
XFILLER_26_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout45 c1.en_tbck VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_4
Xfanout56 net58 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_24_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_50_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1283_ clknet_4_6_0_clk _0295_ _0165_ VGND VGND VPWR VPWR mem1.trellis_diagr\[22\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1352_ clknet_4_10_0_clk _0234_ _0068_ VGND VGND VPWR VPWR mem1.trellis_diagr\[31\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_46_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload9 clknet_4_9_0_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__inv_6
X_0998_ mem1.trellis_diagr\[20\]\[0\] _0353_ _0551_ mem1.trellis_diagr\[21\]\[0\]
+ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__a221o_1
XFILLER_54_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0921_ _0506_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__or2_1
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0852_ _0447_ _0450_ _0453_ _0435_ _0451_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__a221o_1
X_0783_ add1.sum_10\[1\] add1.hamd_4\[1\] VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__and2_1
X_1335_ clknet_4_15_0_clk _0217_ _0051_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1197_ clknet_4_4_0_clk _0011_ _0079_ VGND VGND VPWR VPWR br1.data_rx\[0\] sky130_fd_sc_hd__dfrtp_1
X_1266_ clknet_4_8_0_clk _0278_ _0148_ VGND VGND VPWR VPWR mem1.trellis_diagr\[28\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput2 data[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1120_ net54 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__inv_2
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1051_ net46 VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__inv_2
X_0904_ _0481_ _0495_ net31 VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__o21a_1
XFILLER_33_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0835_ _0436_ _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__and2_1
X_0766_ _0371_ _0372_ _0370_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__o21ai_2
X_0697_ add1.prv_st_00\[0\] net144 _0358_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__mux2_1
X_1318_ clknet_4_11_0_clk _0200_ VGND VGND VPWR VPWR bck_prv_st_01\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1249_ clknet_4_3_0_clk _0261_ _0131_ VGND VGND VPWR VPWR mem1.trellis_diagr\[17\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0620_ tbck1.count\[3\] _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__or2_1
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1103_ net55 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__inv_2
X_1034_ net48 VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__inv_2
XFILLER_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0818_ add1.sum_00\[0\] add1.hamd_1\[0\] VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nand2_2
X_0749_ net44 net151 _0358_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__mux2_1
XFILLER_29_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold107 mem1.count\[3\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
X_0603_ mem1.count\[2\] mem1.count\[1\] mem1.count\[0\] _0311_ VGND VGND VPWR VPWR
+ _0313_ sky130_fd_sc_hd__and4_4
XFILLER_7_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1017_ mem1.trellis_diagr\[8\]\[1\] net35 _0556_ mem1.trellis_diagr\[14\]\[1\] _0580_
+ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__a221o_1
XFILLER_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout57 net58 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_4
XFILLER_22_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout46 net47 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_4
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1351_ clknet_4_2_0_clk _0233_ _0067_ VGND VGND VPWR VPWR mem1.trellis_diagr\[31\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_38_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1282_ clknet_4_3_0_clk _0294_ _0164_ VGND VGND VPWR VPWR mem1.trellis_diagr\[6\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_46_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0997_ mem1.trellis_diagr\[19\]\[0\] _0552_ net33 mem1.trellis_diagr\[17\]\[0\] VGND
+ VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a22o_1
XFILLER_27_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_39_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0920_ add1.sum_10\[2\] _0505_ add1.sum_10\[3\] VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_23_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0851_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__inv_2
X_0782_ _0363_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__xnor2_1
X_1334_ clknet_4_15_0_clk _0216_ _0050_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1265_ clknet_4_8_0_clk _0277_ _0147_ VGND VGND VPWR VPWR mem1.trellis_diagr\[28\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1196_ clknet_4_5_0_clk _0017_ _0078_ VGND VGND VPWR VPWR add1.hamd_3\[1\] sky130_fd_sc_hd__dfrtp_1
Xinput3 data[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1050_ net46 VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__inv_2
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0903_ _0482_ _0495_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__nand2_1
X_0834_ _0428_ _0429_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__xor2_2
X_0765_ _0370_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nand2_1
X_0696_ net126 _0358_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__and2_1
X_1317_ clknet_4_10_0_clk _0199_ _0037_ VGND VGND VPWR VPWR mem1.trellis_diagr\[19\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1248_ clknet_4_8_0_clk _0260_ _0130_ VGND VGND VPWR VPWR mem1.trellis_diagr\[25\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_54_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1179_ net64 VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__inv_2
XFILLER_24_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1102_ net57 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__inv_2
XFILLER_46_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1033_ net48 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__inv_2
X_0817_ add1.sum_00\[1\] add1.hamd_2\[1\] VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_26_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0679_ mem1.count\[2\] _0311_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_10_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0748_ add1.prv_st_10\[0\] net156 _0358_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__mux2_1
XFILLER_52_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold108 tbck1.select_node\[3\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
X_0602_ mem1.count\[0\] _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__nand2_2
XFILLER_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1016_ mem1.trellis_diagr\[15\]\[1\] _0553_ _0555_ mem1.trellis_diagr\[9\]\[1\] _0549_
+ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__a221o_1
XFILLER_1_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout47 net53 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_4
Xfanout58 net18 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_4
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1350_ clknet_4_15_0_clk net87 _0066_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_1
X_1281_ clknet_4_12_0_clk _0293_ _0163_ VGND VGND VPWR VPWR mem1.trellis_diagr\[6\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0996_ net67 _0548_ _0561_ _0564_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__o22a_1
XFILLER_39_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0850_ _0431_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__or2_1
XFILLER_5_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0781_ add1.sum_11\[1\] add1.hamd_3\[1\] VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__xor2_1
X_1333_ clknet_4_15_0_clk _0215_ _0049_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1264_ clknet_4_8_0_clk _0276_ _0146_ VGND VGND VPWR VPWR mem1.trellis_diagr\[12\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput4 data[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_1195_ clknet_4_5_0_clk _0016_ _0077_ VGND VGND VPWR VPWR add1.hamd_3\[0\] sky130_fd_sc_hd__dfrtp_2
X_0979_ net56 _0351_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_40_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0902_ add1.sum_00\[2\] _0498_ add1.en_add VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__mux2_1
X_0833_ _0422_ _0423_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_47_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0695_ mem1.count\[2\] mem1.count\[1\] _0312_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__or3_4
X_0764_ add1.sum_10\[1\] add1.hamd_3\[1\] VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_54_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1178_ net64 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__inv_2
X_1247_ clknet_4_2_0_clk _0259_ _0129_ VGND VGND VPWR VPWR mem1.trellis_diagr\[25\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1316_ clknet_4_6_0_clk _0198_ _0036_ VGND VGND VPWR VPWR mem1.trellis_diagr\[19\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap33 _0555_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_2
XFILLER_7_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1101_ net54 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__inv_2
X_1032_ net46 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__inv_2
XFILLER_23_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0816_ net31 _0419_ _0420_ _0418_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__a31o_1
X_0747_ net72 _0358_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__and2_1
X_0678_ mem1.count\[1\] mem1.count\[0\] VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__or2_2
XFILLER_16_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold109 c1.count\[2\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
X_0601_ mem1.count\[3\] _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nor2_2
XFILLER_7_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1015_ mem1.trellis_diagr\[12\]\[1\] net36 _0551_ mem1.trellis_diagr\[13\]\[1\] VGND
+ VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a22o_1
XFILLER_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout37 net38 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_2
Xfanout59 net61 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_32_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout48 net49 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_4
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1280_ clknet_4_3_0_clk _0292_ _0162_ VGND VGND VPWR VPWR mem1.trellis_diagr\[7\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0995_ mem1.trellis_diagr\[24\]\[1\] net35 _0553_ mem1.trellis_diagr\[31\]\[1\] _0563_
+ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a221o_1
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0780_ add1.sum_11\[1\] add1.hamd_3\[1\] VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__and2_1
X_1332_ clknet_4_15_0_clk _0214_ _0048_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_1194_ clknet_4_4_0_clk _0018_ _0076_ VGND VGND VPWR VPWR add1.hamd_4\[1\] sky130_fd_sc_hd__dfrtp_1
X_1263_ clknet_4_9_0_clk _0275_ _0145_ VGND VGND VPWR VPWR mem1.trellis_diagr\[12\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput5 data[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0978_ net56 _0351_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__nor2_2
XFILLER_42_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0901_ _0485_ _0484_ _0495_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__mux2_1
X_0832_ _0425_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__nor2_1
X_0763_ add1.sum_10\[1\] add1.hamd_3\[1\] VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__nor2_1
XFILLER_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0694_ net158 add1.prv_st_00\[0\] _0357_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__mux2_1
X_1315_ clknet_4_11_0_clk _0197_ VGND VGND VPWR VPWR bck_prv_st_10\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1177_ net63 VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__inv_2
X_1246_ clknet_4_10_0_clk _0258_ _0128_ VGND VGND VPWR VPWR mem1.trellis_diagr\[18\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap34 _0550_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_2
XFILLER_30_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
X_1100_ net54 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__inv_2
XFILLER_16_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1031_ net104 _0593_ _0548_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__mux2_1
X_0815_ _0408_ _0409_ _0384_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a21o_1
X_0746_ net91 add1.prv_st_10\[0\] net30 VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__mux2_1
X_0677_ _0312_ _0347_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__and2_1
X_1229_ clknet_4_13_0_clk _0245_ _0111_ VGND VGND VPWR VPWR add1.sum_00\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_7_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0600_ c1.en_tbck c1.state\[4\] VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__nor2_1
XFILLER_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1014_ net71 _0548_ _0579_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__o21a_1
X_0729_ net135 net43 net28 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__mux2_1
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout38 _0336_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_4
Xfanout49 net53 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_32_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0994_ mem1.trellis_diagr\[28\]\[1\] net36 _0551_ mem1.trellis_diagr\[29\]\[1\] _0562_
+ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a221o_1
XFILLER_8_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1331_ clknet_4_15_0_clk _0213_ _0047_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1262_ clknet_4_8_0_clk _0274_ _0144_ VGND VGND VPWR VPWR mem1.trellis_diagr\[13\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput6 data[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1193_ clknet_4_6_0_clk _0241_ _0075_ VGND VGND VPWR VPWR add1.sum_11\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_34_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0977_ net17 net169 VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__and2b_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0900_ _0497_ _0496_ net32 add1.sum_00\[3\] VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0831_ add1.sum_00\[2\] _0424_ add1.sum_00\[3\] VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a21oi_1
X_0762_ add1.sum_10\[0\] add1.hamd_3\[0\] VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__nand2_2
X_0693_ _0357_ net92 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__and2b_1
XFILLER_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ clknet_4_11_0_clk _0196_ VGND VGND VPWR VPWR bck_prv_st_10\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1245_ clknet_4_6_0_clk _0257_ _0127_ VGND VGND VPWR VPWR mem1.trellis_diagr\[18\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1176_ net63 VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__inv_2
Xmax_cap35 _0354_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_2
XFILLER_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1030_ mem1.trellis_diagr\[0\]\[1\] _0355_ _0590_ _0592_ VGND VGND VPWR VPWR _0593_
+ sky130_fd_sc_hd__o22a_1
X_0814_ _0386_ _0408_ _0409_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand3_1
XFILLER_21_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0676_ mem1.count\[0\] _0311_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__or2_1
X_0745_ net29 net138 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__and2b_1
X_1228_ clknet_4_7_0_clk _0244_ _0110_ VGND VGND VPWR VPWR add1.sum_00\[2\] sky130_fd_sc_hd__dfrtp_2
X_1159_ net61 VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__inv_2
XFILLER_16_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1013_ _0549_ _0576_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__or3_1
X_0659_ net17 c1.count\[1\] c1.count\[0\] VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0728_ net80 add1.prv_st_01\[0\] _0360_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__mux2_1
XFILLER_25_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_25_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout39 tbck1.count\[1\] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_32_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0993_ mem1.trellis_diagr\[25\]\[1\] _0555_ _0556_ mem1.trellis_diagr\[30\]\[1\]
+ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__a22o_1
XFILLER_39_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1330_ clknet_4_14_0_clk _0212_ _0046_ VGND VGND VPWR VPWR tbck1.sel_bit_out\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1261_ clknet_4_9_0_clk _0273_ _0143_ VGND VGND VPWR VPWR mem1.trellis_diagr\[13\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_34_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1192_ clknet_4_3_0_clk _0240_ _0074_ VGND VGND VPWR VPWR add1.sum_11\[3\] sky130_fd_sc_hd__dfrtp_1
Xinput7 data[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_0976_ net31 _0457_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__and2_1
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0830_ add1.sum_10\[4\] _0336_ _0426_ _0433_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__a22o_1
XFILLER_41_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0692_ mem1.count\[3\] mem1.count\[2\] _0310_ _0348_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nor4_1
X_0761_ add1.sum_10\[1\] add1.hamd_3\[1\] VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__nand2_1
XFILLER_49_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1244_ clknet_4_13_0_clk _0007_ _0126_ VGND VGND VPWR VPWR add1.prv_st_00\[0\] sky130_fd_sc_hd__dfrtp_2
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1313_ clknet_4_10_0_clk _0195_ VGND VGND VPWR VPWR bck_prv_st_11\[1\] sky130_fd_sc_hd__dfxtp_1
X_1175_ net63 VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_44_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0959_ _0540_ _0541_ br1.count\[3\] VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__mux2_1
XFILLER_47_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap36 _0353_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_2
XFILLER_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0813_ add1.sum_01\[0\] net37 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__and2_1
Xinput10 data[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_0675_ net170 _0312_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__xnor2_1
X_0744_ net139 add1.prv_st_11\[0\] _0359_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__mux2_1
X_1227_ clknet_4_7_0_clk _0243_ _0109_ VGND VGND VPWR VPWR add1.sum_00\[1\] sky130_fd_sc_hd__dfrtp_2
X_1158_ net60 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__inv_2
XFILLER_32_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1089_ net49 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__inv_2
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1012_ mem1.trellis_diagr\[8\]\[0\] net35 _0552_ mem1.trellis_diagr\[11\]\[0\] _0577_
+ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__a221o_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0727_ net159 net43 _0360_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0658_ br1.count\[1\] _0337_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__xnor2_1
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0992_ mem1.trellis_diagr\[26\]\[1\] net34 _0552_ mem1.trellis_diagr\[27\]\[1\] _0549_
+ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__a221o_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_54_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1260_ clknet_4_10_0_clk _0272_ _0142_ VGND VGND VPWR VPWR mem1.trellis_diagr\[24\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput8 data[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_1191_ clknet_4_3_0_clk _0239_ _0073_ VGND VGND VPWR VPWR add1.sum_11\[2\] sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_34_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0975_ _0336_ _0495_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__nor2_1
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0760_ add1.sum_11\[4\] _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__xor2_2
X_0691_ net42 _0351_ _0356_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__a21bo_1
XFILLER_49_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1174_ net62 VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__inv_2
X_1243_ clknet_4_6_0_clk _0256_ _0125_ VGND VGND VPWR VPWR add1.sum_01\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1312_ clknet_4_10_0_clk _0194_ VGND VGND VPWR VPWR bck_prv_st_11\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0889_ _0438_ _0445_ _0446_ _0484_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__o32a_1
X_0958_ br1.data_reg\[8\] br1.data_reg\[10\] br1.data_reg\[12\] br1.data_reg\[14\]
+ br1.count\[1\] br1.count\[2\] VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_53_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0812_ net31 _0416_ _0417_ _0415_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a31o_1
X_0743_ net155 net43 _0359_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__mux2_1
Xinput11 data[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_0674_ _0345_ _0346_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__or2_1
XFILLER_52_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1157_ net60 VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__inv_2
X_1226_ clknet_4_5_0_clk _0242_ _0108_ VGND VGND VPWR VPWR add1.sum_00\[0\] sky130_fd_sc_hd__dfrtp_1
X_1088_ net57 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__inv_2
XFILLER_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1011_ mem1.trellis_diagr\[15\]\[0\] _0553_ _0556_ mem1.trellis_diagr\[14\]\[0\]
+ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_12_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0726_ net108 add1.prv_st_10\[0\] _0313_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0657_ _0339_ _0340_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__nand2_1
XFILLER_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1209_ clknet_4_1_0_clk net14 _0091_ VGND VGND VPWR VPWR br1.data_reg\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0709_ net95 add1.prv_st_00\[0\] _0350_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__mux2_1
XFILLER_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0991_ net68 _0548_ _0560_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__o21a_1
XFILLER_39_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput9 data[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_1190_ clknet_4_1_0_clk _0238_ _0072_ VGND VGND VPWR VPWR add1.sum_11\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0974_ net38 _0519_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__nor2_1
XFILLER_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
X_0690_ _0352_ net36 _0356_ net41 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__a22o_1
XFILLER_25_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1311_ clknet_4_10_0_clk _0193_ _0035_ VGND VGND VPWR VPWR mem1.trellis_diagr\[27\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1173_ net64 VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__inv_2
X_1242_ clknet_4_7_0_clk _0255_ _0124_ VGND VGND VPWR VPWR add1.sum_01\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0888_ add1.sum_01\[2\] _0468_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__xnor2_1
X_0957_ br1.data_reg\[0\] br1.data_reg\[2\] br1.data_reg\[4\] br1.data_reg\[6\] br1.count\[1\]
+ br1.count\[2\] VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__mux4_1
XFILLER_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0673_ _0308_ _0312_ mem1.count\[2\] VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__o21a_1
X_0811_ _0408_ _0409_ _0399_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a21o_1
X_0742_ net124 add1.prv_st_01\[0\] _0313_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__mux2_1
Xinput12 data[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1156_ net60 VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__inv_2
XFILLER_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1225_ clknet_4_2_0_clk _0010_ _0107_ VGND VGND VPWR VPWR add1.prv_st_11\[0\] sky130_fd_sc_hd__dfrtp_2
XFILLER_16_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1087_ net59 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__inv_2
XFILLER_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1010_ mem1.trellis_diagr\[12\]\[0\] net36 _0555_ mem1.trellis_diagr\[9\]\[0\] _0575_
+ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__a221o_1
XFILLER_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0725_ _0313_ net121 VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__and2b_1
X_0656_ br1.count\[1\] _0337_ br1.count\[2\] VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_4_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1208_ clknet_4_1_0_clk net13 _0090_ VGND VGND VPWR VPWR br1.data_reg\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1139_ net59 VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__inv_2
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1 net27 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_49_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0639_ _0315_ _0323_ _0324_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__and3_1
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0708_ _0348_ _0349_ net70 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__o21a_1
XFILLER_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0990_ _0549_ _0558_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_20_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0973_ net32 _0408_ _0409_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__and3_1
XFILLER_35_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1241_ clknet_4_7_0_clk _0254_ _0123_ VGND VGND VPWR VPWR add1.sum_01\[2\] sky130_fd_sc_hd__dfrtp_4
X_1310_ clknet_4_2_0_clk _0192_ _0034_ VGND VGND VPWR VPWR mem1.trellis_diagr\[27\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1172_ net64 VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__inv_2
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0956_ _0307_ _0539_ _0310_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__a21oi_1
XFILLER_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0887_ add1.sum_01\[2\] _0468_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__xor2_1
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap28 _0345_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_2
XFILLER_11_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0810_ _0398_ _0408_ _0409_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nand3_1
XFILLER_14_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 data[6] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
X_0672_ net172 _0313_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__or2_1
X_0741_ net117 net43 _0313_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__mux2_1
X_1224_ clknet_4_13_0_clk net166 _0106_ VGND VGND VPWR VPWR c1.state\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1086_ net60 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__inv_2
XFILLER_37_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1155_ net57 VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__inv_2
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0939_ _0386_ _0519_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__nor2_1
XFILLER_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0724_ add1.prv_st_01\[0\] net145 _0358_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__mux2_1
X_0655_ br1.count\[3\] _0339_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__xnor2_1
X_1207_ clknet_4_4_0_clk net12 _0089_ VGND VGND VPWR VPWR br1.data_reg\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1069_ net51 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__inv_2
XFILLER_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1138_ net58 VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__inv_2
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold2 bck_prv_st_11\[1\] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dlygate4sd3_1
X_0707_ net161 add1.prv_st_11\[0\] _0360_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__mux2_1
X_0638_ tbck1.in_bit net148 _0329_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__mux2_1
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0972_ br1.data_rx\[0\] net176 _0338_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_34_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_38_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1171_ net62 VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__inv_2
X_1240_ clknet_4_7_0_clk _0253_ _0122_ VGND VGND VPWR VPWR add1.sum_01\[1\] sky130_fd_sc_hd__dfrtp_2
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0886_ add1.sum_00\[2\] _0475_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__xor2_1
XFILLER_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0955_ net45 net168 _0537_ _0535_ net173 VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__a32o_1
Xmax_cap29 net30 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XFILLER_11_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0740_ add1.prv_st_01\[0\] net152 _0361_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__mux2_1
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput14 data[7] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
X_0671_ net146 add1.prv_st_11\[0\] net28 VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__mux2_1
X_1223_ clknet_4_13_0_clk _0001_ _0105_ VGND VGND VPWR VPWR c1.en_tbck sky130_fd_sc_hd__dfrtp_2
X_1154_ net53 VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__inv_2
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1085_ net52 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__inv_2
X_0869_ _0428_ _0465_ _0464_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__o21ai_2
X_0938_ net38 _0526_ _0527_ _0528_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__o31a_1
XFILLER_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0723_ net44 net142 _0358_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__mux2_1
XFILLER_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0654_ br1.count\[2\] br1.count\[1\] _0337_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__or3_1
X_1206_ clknet_4_1_0_clk net11 _0088_ VGND VGND VPWR VPWR br1.data_reg\[4\] sky130_fd_sc_hd__dfrtp_1
X_1137_ net58 VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_25_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1068_ net51 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__inv_2
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold3 bck_prv_st_11\[0\] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_17_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
X_0706_ net162 net43 _0360_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__mux2_1
X_0637_ tbck1.count\[1\] net40 _0316_ tbck1.count\[2\] VGND VGND VPWR VPWR _0329_
+ sky130_fd_sc_hd__or4b_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0971_ _0014_ _0015_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__or2_1
XFILLER_27_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1170_ net62 VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__inv_2
XFILLER_32_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0885_ _0438_ _0445_ _0481_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__o22ai_1
X_0954_ net165 net17 c1.state\[4\] _0539_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__a22o_1
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1299_ clknet_4_14_0_clk _0181_ _0023_ VGND VGND VPWR VPWR mem1.trellis_diagr\[0\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_23_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0670_ net137 net43 net28 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__mux2_1
Xinput15 data[8] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
X_1222_ clknet_4_13_0_clk _0000_ _0104_ VGND VGND VPWR VPWR c1.state\[0\] sky130_fd_sc_hd__dfstp_1
XFILLER_37_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1084_ net52 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__inv_2
X_1153_ net57 VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__inv_2
X_0868_ _0464_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nand2_1
X_0799_ _0369_ _0377_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__nor2_1
X_0937_ add1.sum_11\[1\] net32 VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__or2_1
XFILLER_28_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0653_ c1.state\[3\] net31 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__or2_1
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0722_ net83 add1.prv_st_01\[0\] net30 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__mux2_1
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1136_ net62 VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__inv_2
X_1067_ net49 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__inv_2
X_1205_ clknet_4_1_0_clk net10 _0087_ VGND VGND VPWR VPWR br1.data_reg\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold4 c1.count\[3\] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_39_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0636_ net120 _0327_ _0328_ _0325_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__a22o_1
X_0705_ net115 add1.prv_st_00\[0\] _0345_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__mux2_1
XFILLER_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1119_ net49 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_0_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0619_ c1.en_tbck tbck1.count\[2\] net39 net40 VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__nand4_1
XFILLER_26_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
X_0970_ _0337_ _0547_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__nor2_1
XFILLER_4_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0884_ _0422_ _0474_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__xnor2_1
X_0953_ c1.count\[2\] _0341_ net17 c1.count\[3\] VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__o211ai_1
X_1298_ clknet_4_3_0_clk _0180_ _0022_ VGND VGND VPWR VPWR mem1.trellis_diagr\[1\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_23_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput16 data[9] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
X_1221_ clknet_4_11_0_clk _0006_ _0103_ VGND VGND VPWR VPWR tbck1.select_node\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_1083_ net52 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__inv_2
XFILLER_37_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1152_ net49 VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__inv_2
X_0936_ _0399_ _0519_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__and2_1
X_0867_ add1.sum_01\[1\] add1.hamd_2\[1\] VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__or2_1
X_0798_ _0401_ _0402_ _0405_ _0382_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__o22a_1
XFILLER_11_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0652_ c1.state\[3\] net31 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__nor2_2
X_0721_ net100 net44 net29 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_12_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1204_ clknet_4_1_0_clk net9 _0086_ VGND VGND VPWR VPWR br1.data_reg\[2\] sky130_fd_sc_hd__dfrtp_1
X_1066_ net60 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__inv_2
X_1135_ net62 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__inv_2
X_0919_ _0503_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__nor2_1
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold5 mem1.trellis_diagr\[4\]\[1\] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_17_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0635_ net39 tbck1.count\[0\] tbck1.in_bit VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__and3b_1
X_0704_ net28 net82 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__and2b_1
XFILLER_53_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1118_ net55 VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__inv_2
X_1049_ net46 VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__inv_2
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0618_ c1.en_tbck net40 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__nand2_1
XFILLER_53_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0952_ net45 tbck1.select_node\[1\] _0533_ _0531_ net167 VGND VGND VPWR VPWR _0003_
+ sky130_fd_sc_hd__a32o_1
X_0883_ _0428_ _0467_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__xor2_1
X_1297_ clknet_4_12_0_clk _0179_ _0021_ VGND VGND VPWR VPWR mem1.trellis_diagr\[1\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_46_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput17 en VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_2
X_1151_ net61 VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__inv_2
X_1220_ clknet_4_11_0_clk _0005_ _0102_ VGND VGND VPWR VPWR tbck1.select_node\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1082_ net51 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__inv_2
X_0866_ add1.sum_01\[1\] add1.hamd_2\[1\] VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__nor2_1
X_0935_ _0398_ _0519_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nor2_1
X_0797_ _0376_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__nor2_1
X_1349_ clknet_4_14_0_clk _0231_ _0065_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_1
XFILLER_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0720_ add1.prv_st_11\[0\] net141 _0361_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__mux2_1
X_0651_ net38 VGND VGND VPWR VPWR add1.en_add sky130_fd_sc_hd__inv_2
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1203_ clknet_4_1_0_clk net8 _0085_ VGND VGND VPWR VPWR br1.data_reg\[1\] sky130_fd_sc_hd__dfrtp_1
X_1134_ net48 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__inv_2
X_1065_ net60 VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__inv_2
X_0849_ add1.sum_01\[2\] _0430_ add1.sum_01\[3\] VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__a21oi_1
X_0918_ add1.sum_11\[2\] _0502_ add1.sum_11\[3\] VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_3_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 bck_prv_st_01\[0\] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0703_ net129 add1.prv_st_00\[0\] _0360_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_29_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0634_ tbck1.count\[2\] _0321_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_13_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1117_ net54 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1048_ net46 VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__inv_2
XFILLER_21_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0617_ tbck1.count\[3\] _0307_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__or2_1
XFILLER_41_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_16_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0882_ _0476_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__and2_1
X_0951_ _0307_ tbck1.select_node\[1\] _0536_ _0538_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__a211o_1
X_1296_ clknet_4_9_0_clk _0178_ _0020_ VGND VGND VPWR VPWR mem1.trellis_diagr\[21\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput18 rst VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_2
XFILLER_14_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1150_ net59 VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__inv_2
XFILLER_52_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1081_ net50 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__inv_2
X_0865_ add1.sum_01\[1\] add1.hamd_2\[1\] VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand2_1
X_0934_ add1.sum_11\[2\] net32 _0524_ _0525_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__o22a_1
X_0796_ add1.sum_10\[2\] _0375_ add1.sum_10\[3\] VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a21oi_1
X_1348_ clknet_4_15_0_clk net90 _0064_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_1
XFILLER_43_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1279_ clknet_4_14_0_clk _0291_ _0161_ VGND VGND VPWR VPWR mem1.trellis_diagr\[7\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0650_ c1.state\[2\] c1.state\[4\] VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__nor2_1
X_1064_ net60 VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__inv_2
X_1202_ clknet_4_0_0_clk net1 _0084_ VGND VGND VPWR VPWR br1.data_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1133_ net62 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__inv_2
XFILLER_18_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0848_ _0448_ _0449_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2_1
X_0917_ _0509_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
X_0779_ _0384_ _0386_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_3_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 mem1.trellis_diagr\[17\]\[1\] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_15_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0702_ _0360_ net114 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__and2b_1
X_0633_ net75 tbck1.in_bit _0326_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1116_ net56 VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__inv_2
X_1047_ net46 VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__inv_2
XFILLER_21_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0616_ tbck1.count\[3\] _0307_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nor2_1
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0881_ add1.sum_00\[2\] _0475_ add1.sum_00\[3\] VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a21o_1
X_0950_ bck_prv_st_01\[0\] bck_prv_st_01\[1\] tbck1.select_node\[2\] net45 VGND VGND
+ VPWR VPWR _0538_ sky130_fd_sc_hd__and4b_1
X_1295_ clknet_4_9_0_clk _0177_ _0019_ VGND VGND VPWR VPWR mem1.trellis_diagr\[21\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1080_ net52 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__inv_2
XFILLER_45_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0864_ add1.sum_10\[0\] _0463_ net31 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__mux2_1
XFILLER_13_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0933_ _0401_ _0519_ net38 VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21o_1
X_0795_ _0397_ _0400_ _0401_ _0402_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a22o_1
X_1347_ clknet_4_15_0_clk net123 _0063_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1278_ clknet_4_8_0_clk _0290_ _0160_ VGND VGND VPWR VPWR mem1.trellis_diagr\[30\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1201_ clknet_4_5_0_clk _0014_ _0083_ VGND VGND VPWR VPWR add1.hamd_1\[1\] sky130_fd_sc_hd__dfrtp_2
X_1132_ net57 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__inv_2
X_1063_ net58 VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__inv_2
XFILLER_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0916_ add1.sum_10\[2\] _0505_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__xor2_1
X_0847_ _0439_ _0445_ _0448_ _0449_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__o2bb2a_1
X_0778_ _0363_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_3_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold8 tbck1.sel_bit_out\[3\] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_30_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0632_ net40 _0315_ tbck1.count\[2\] net39 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__and4b_1
X_0701_ mem1.count\[2\] mem1.count\[0\] _0311_ mem1.count\[1\] VGND VGND VPWR VPWR
+ _0360_ sky130_fd_sc_hd__and4bb_4
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1115_ net55 VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__inv_2
X_1046_ net46 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__inv_2
XFILLER_12_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0615_ tbck1.count\[3\] c1.en_tbck net66 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__a21o_1
XFILLER_38_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1029_ mem1.trellis_diagr\[5\]\[1\] _0551_ _0591_ _0354_ VGND VGND VPWR VPWR _0592_
+ sky130_fd_sc_hd__a211o_1
XFILLER_44_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0880_ add1.sum_00\[4\] net37 _0470_ _0478_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_53_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1294_ clknet_4_14_0_clk _0306_ _0176_ VGND VGND VPWR VPWR mem1.trellis_diagr\[2\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_31_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0932_ _0402_ _0519_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__nor2_1
X_0863_ _0444_ _0441_ _0457_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__mux2_1
X_0794_ add1.sum_11\[2\] _0367_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__xnor2_2
X_1346_ clknet_4_15_0_clk _0228_ _0062_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1277_ clknet_4_2_0_clk _0289_ _0159_ VGND VGND VPWR VPWR mem1.trellis_diagr\[30\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1200_ clknet_4_5_0_clk _0013_ _0082_ VGND VGND VPWR VPWR add1.hamd_1\[0\] sky130_fd_sc_hd__dfrtp_2
XFILLER_26_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1131_ net54 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__inv_2
X_1062_ net56 VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__inv_2
X_0915_ add1.sum_11\[2\] _0502_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__xnor2_1
X_0846_ add1.sum_01\[2\] _0430_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0777_ add1.sum_11\[0\] add1.hamd_3\[0\] VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_3_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1329_ clknet_4_11_0_clk _0211_ _0045_ VGND VGND VPWR VPWR tbck1.in_bit sky130_fd_sc_hd__dfrtp_2
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold9 c1.count\[0\] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dlygate4sd3_1
X_0700_ net143 add1.prv_st_10\[0\] _0359_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__mux2_1
X_0631_ net136 _0319_ _0322_ _0325_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__a22o_1
XFILLER_2_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1114_ net57 VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
X_1045_ net46 VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__inv_2
X_0829_ _0336_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nor2_1
XFILLER_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0614_ tbck1.sel_bit_out\[0\] net78 _0314_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1028_ mem1.trellis_diagr\[4\]\[1\] _0353_ _0550_ mem1.trellis_diagr\[2\]\[1\] VGND
+ VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a22o_1
XFILLER_29_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1293_ clknet_4_14_0_clk _0305_ _0175_ VGND VGND VPWR VPWR mem1.trellis_diagr\[2\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_53_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0862_ _0461_ _0462_ add1.sum_10\[1\] net37 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_15_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0931_ net38 _0521_ _0522_ _0523_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__o31a_1
XFILLER_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0793_ add1.sum_10\[2\] _0375_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__xor2_2
X_1345_ clknet_4_15_0_clk net102 _0061_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_1
X_1276_ clknet_4_8_0_clk _0288_ _0158_ VGND VGND VPWR VPWR mem1.trellis_diagr\[8\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1130_ net59 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__inv_2
XFILLER_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1061_ net56 VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__inv_2
X_0845_ add1.sum_00\[2\] _0424_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__xor2_1
XFILLER_33_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0914_ _0395_ _0396_ _0394_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__a21o_1
X_0776_ _0371_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__and2_1
X_1259_ clknet_4_8_0_clk _0271_ _0141_ VGND VGND VPWR VPWR mem1.trellis_diagr\[24\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1328_ clknet_4_1_0_clk _0210_ _0044_ VGND VGND VPWR VPWR br1.count\[3\] sky130_fd_sc_hd__dfstp_1
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0630_ _0323_ _0324_ _0316_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_0_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1044_ net47 VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__inv_2
X_1113_ net55 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__inv_2
XFILLER_21_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0828_ add1.sum_01\[4\] _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_31_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0759_ add1.sum_11\[3\] add1.sum_11\[2\] _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_39_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0613_ tbck1.sel_bit_out\[1\] net84 _0314_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__mux2_1
XFILLER_7_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1027_ mem1.trellis_diagr\[7\]\[1\] _0553_ _0556_ mem1.trellis_diagr\[6\]\[1\] _0589_
+ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a221o_1
XFILLER_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold90 mem1.trellis_diagr\[29\]\[1\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1292_ clknet_4_3_0_clk _0304_ _0174_ VGND VGND VPWR VPWR mem1.trellis_diagr\[3\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0861_ _0437_ _0457_ net37 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__a21o_1
XFILLER_9_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0930_ add1.sum_11\[3\] net32 VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__or2_1
X_0792_ _0387_ _0395_ _0398_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__a22o_1
XFILLER_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1344_ clknet_4_15_0_clk net85 _0060_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_1
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1275_ clknet_4_9_0_clk _0287_ _0157_ VGND VGND VPWR VPWR mem1.trellis_diagr\[8\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_28_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1060_ net56 VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__inv_2
XFILLER_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0844_ _0438_ _0445_ _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__or3_1
X_0913_ add1.sum_10\[4\] _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__xor2_1
X_0775_ add1.sum_10\[0\] add1.hamd_3\[0\] VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__or2_1
X_1258_ clknet_4_8_0_clk _0270_ _0140_ VGND VGND VPWR VPWR mem1.trellis_diagr\[14\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1327_ clknet_4_0_0_clk _0209_ _0043_ VGND VGND VPWR VPWR br1.count\[2\] sky130_fd_sc_hd__dfstp_1
X_1189_ clknet_4_4_0_clk _0237_ _0071_ VGND VGND VPWR VPWR add1.sum_11\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1043_ net51 VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__inv_2
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1112_ net57 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_0_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0827_ add1.sum_01\[3\] add1.sum_01\[2\] _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_31_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0758_ _0363_ _0364_ _0362_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_39_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0689_ net42 _0351_ _0354_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__or3_1
XFILLER_29_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0612_ tbck1.sel_bit_out\[2\] net101 _0314_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__mux2_1
XFILLER_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1026_ mem1.trellis_diagr\[3\]\[1\] _0552_ net33 mem1.trellis_diagr\[1\]\[1\] VGND
+ VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a22o_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold80 mem1.trellis_diagr\[9\]\[0\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold91 mem1.trellis_diagr\[17\]\[0\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1009_ mem1.trellis_diagr\[10\]\[0\] net34 _0551_ mem1.trellis_diagr\[13\]\[0\] VGND
+ VGND VPWR VPWR _0575_ sky130_fd_sc_hd__a22o_1
XFILLER_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1291_ clknet_4_14_0_clk _0303_ _0173_ VGND VGND VPWR VPWR mem1.trellis_diagr\[3\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0860_ _0436_ _0457_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nor2_1
XFILLER_42_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0791_ _0371_ _0374_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__xor2_1
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1343_ clknet_4_14_0_clk net79 _0059_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_1
X_1274_ clknet_4_8_0_clk _0286_ _0156_ VGND VGND VPWR VPWR mem1.trellis_diagr\[9\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0989_ mem1.trellis_diagr\[28\]\[0\] net36 _0552_ mem1.trellis_diagr\[27\]\[0\] _0557_
+ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a221o_1
XFILLER_47_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0912_ add1.sum_10\[3\] add1.sum_10\[2\] _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_28_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0843_ _0442_ _0444_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__and2_1
X_0774_ _0368_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__or2_1
X_1326_ clknet_4_1_0_clk _0208_ _0042_ VGND VGND VPWR VPWR br1.count\[1\] sky130_fd_sc_hd__dfstp_2
X_1188_ net60 VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__inv_2
X_1257_ clknet_4_2_0_clk _0269_ _0139_ VGND VGND VPWR VPWR mem1.trellis_diagr\[14\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_49_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1042_ net51 VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__inv_2
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1111_ net55 VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0826_ add1.sum_01\[0\] add1.hamd_1\[0\] _0429_ _0427_ VGND VGND VPWR VPWR _0430_
+ sky130_fd_sc_hd__a31o_1
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0688_ mem1.trace\[2\] mem1.trace\[1\] mem1.trace\[0\] VGND VGND VPWR VPWR _0355_
+ sky130_fd_sc_hd__or3_1
X_0757_ _0362_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_39_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1309_ clknet_4_12_0_clk _0191_ _0033_ VGND VGND VPWR VPWR mem1.count\[3\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0611_ net73 net88 _0314_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__mux2_1
XFILLER_38_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1025_ net134 _0588_ _0548_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__mux2_1
X_0809_ add1.sum_01\[1\] net38 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__and2_1
XFILLER_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold70 mem1.trellis_diagr\[11\]\[1\] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 mem1.trellis_diagr\[27\]\[0\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 mem1.trellis_diagr\[14\]\[1\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1008_ net149 _0548_ _0574_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__o21a_1
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1290_ clknet_4_10_0_clk _0302_ _0172_ VGND VGND VPWR VPWR mem1.trellis_diagr\[26\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0790_ _0363_ _0366_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__xnor2_1
X_1342_ clknet_4_14_0_clk _0224_ _0058_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_1
X_1273_ clknet_4_9_0_clk _0285_ _0155_ VGND VGND VPWR VPWR mem1.trellis_diagr\[9\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0988_ mem1.trellis_diagr\[26\]\[0\] net34 _0551_ mem1.trellis_diagr\[29\]\[0\] _0554_
+ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a221o_1
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0842_ _0436_ _0437_ _0442_ _0444_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__o22ai_2
X_0911_ add1.sum_10\[0\] add1.hamd_3\[0\] _0392_ _0391_ VGND VGND VPWR VPWR _0505_
+ sky130_fd_sc_hd__a31o_1
XFILLER_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0773_ add1.sum_11\[2\] _0367_ add1.sum_11\[3\] VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__a21oi_1
X_1325_ clknet_4_13_0_clk _0207_ _0041_ VGND VGND VPWR VPWR c1.count\[3\] sky130_fd_sc_hd__dfrtp_1
X_1256_ clknet_4_11_0_clk _0268_ _0138_ VGND VGND VPWR VPWR mem1.trellis_diagr\[15\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1187_ net60 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__inv_2
XFILLER_33_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1110_ net57 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__inv_2
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1041_ net51 VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__inv_2
X_0825_ add1.sum_01\[1\] add1.hamd_1\[1\] VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_31_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0756_ add1.sum_11\[1\] add1.hamd_4\[1\] VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__or2_1
X_0687_ mem1.trace\[2\] net41 net42 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__nor3_2
XTAP_TAPCELL_ROW_39_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1239_ clknet_4_7_0_clk _0252_ _0121_ VGND VGND VPWR VPWR add1.sum_01\[0\] sky130_fd_sc_hd__dfrtp_1
X_1308_ clknet_4_12_0_clk _0190_ _0032_ VGND VGND VPWR VPWR mem1.count\[2\] sky130_fd_sc_hd__dfrtp_4
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0610_ tbck1.sel_bit_out\[4\] net122 _0314_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__mux2_1
XFILLER_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1024_ mem1.trellis_diagr\[0\]\[0\] _0355_ _0584_ _0587_ VGND VGND VPWR VPWR _0588_
+ sky130_fd_sc_hd__o22a_1
XFILLER_26_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0808_ net31 _0413_ _0414_ _0412_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__a31o_1
XFILLER_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0739_ net44 net157 _0361_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__mux2_1
XFILLER_52_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold71 tbck1.sel_bit_out\[7\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 mem1.trellis_diagr\[22\]\[0\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 mem1.trellis_diagr\[0\]\[0\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 mem1.trellis_diagr\[28\]\[1\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1007_ _0549_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__or3_1
XFILLER_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1341_ clknet_4_15_0_clk _0223_ _0057_ VGND VGND VPWR VPWR tbck1.count\[3\] sky130_fd_sc_hd__dfrtp_2
X_1272_ clknet_4_10_0_clk _0284_ _0154_ VGND VGND VPWR VPWR mem1.trellis_diagr\[23\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0987_ mem1.trellis_diagr\[25\]\[0\] net33 _0556_ mem1.trellis_diagr\[30\]\[0\] VGND
+ VGND VPWR VPWR _0557_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_14_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0841_ _0422_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__and2_1
X_0772_ add1.sum_01\[3\] net37 VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0910_ add1.sum_11\[4\] _0503_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__xnor2_1
XFILLER_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1324_ clknet_4_13_0_clk _0206_ _0040_ VGND VGND VPWR VPWR c1.count\[2\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1255_ clknet_4_2_0_clk _0267_ _0137_ VGND VGND VPWR VPWR mem1.trellis_diagr\[15\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_1186_ net57 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1040_ net50 VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_48_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0824_ add1.sum_01\[0\] add1.hamd_1\[0\] VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__nand2_2
X_0755_ add1.sum_11\[1\] add1.hamd_4\[1\] VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nor2_1
X_0686_ net41 net42 _0351_ net171 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__o31a_1
XFILLER_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1169_ net64 VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__inv_2
X_1238_ clknet_4_13_0_clk _0251_ _0120_ VGND VGND VPWR VPWR add1.sum_10\[4\] sky130_fd_sc_hd__dfrtp_2
X_1307_ clknet_4_12_0_clk _0189_ _0031_ VGND VGND VPWR VPWR mem1.count\[1\] sky130_fd_sc_hd__dfrtp_2
XFILLER_20_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1023_ mem1.trellis_diagr\[2\]\[0\] _0550_ _0585_ _0586_ VGND VGND VPWR VPWR _0587_
+ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_44_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0807_ _0408_ _0409_ _0401_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a21o_1
X_0738_ net99 add1.prv_st_11\[0\] net29 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_12_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0669_ net110 add1.prv_st_10\[0\] _0345_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__mux2_1
XFILLER_29_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold83 tbck1.sel_bit_out\[4\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 mem1.trellis_diagr\[27\]\[1\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 mem1.trellis_diagr\[10\]\[1\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 mem1.trellis_diagr\[1\]\[1\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 mem1.trellis_diagr\[3\]\[0\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_41_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1006_ mem1.trellis_diagr\[16\]\[1\] net35 _0553_ mem1.trellis_diagr\[23\]\[1\] _0570_
+ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a221o_1
XFILLER_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_9_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1340_ clknet_4_15_0_clk _0222_ _0056_ VGND VGND VPWR VPWR tbck1.count\[2\] sky130_fd_sc_hd__dfrtp_2
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1271_ clknet_4_3_0_clk _0283_ _0153_ VGND VGND VPWR VPWR mem1.trellis_diagr\[23\]\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0986_ net42 net41 mem1.trace\[2\] VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__and3b_2
XFILLER_47_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0840_ add1.sum_00\[0\] add1.hamd_1\[0\] VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__or2_1
X_0771_ add1.sum_01\[4\] net38 _0369_ _0379_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a22o_1
X_1323_ clknet_4_13_0_clk _0205_ _0039_ VGND VGND VPWR VPWR c1.count\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1254_ clknet_4_8_0_clk _0266_ _0136_ VGND VGND VPWR VPWR mem1.trellis_diagr\[29\]\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_1185_ net49 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__inv_2
XFILLER_33_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0969_ _0338_ _0546_ _0547_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_2_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0823_ add1.sum_01\[1\] add1.hamd_1\[1\] VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and2_1
X_0685_ net41 net42 mem1.trace\[2\] VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nor3b_2
X_0754_ add1.sum_11\[0\] add1.hamd_3\[0\] VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__nand2_2
X_1306_ clknet_4_12_0_clk _0188_ _0030_ VGND VGND VPWR VPWR mem1.count\[0\] sky130_fd_sc_hd__dfrtp_2
X_1168_ net64 VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__inv_2
XFILLER_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1237_ clknet_4_6_0_clk _0250_ _0119_ VGND VGND VPWR VPWR add1.sum_10\[3\] sky130_fd_sc_hd__dfrtp_1
X_1099_ net49 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1022_ mem1.trellis_diagr\[5\]\[0\] _0551_ _0556_ mem1.trellis_diagr\[6\]\[0\] VGND
+ VGND VPWR VPWR _0586_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_44_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0806_ _0402_ _0408_ _0409_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nand3_1
X_0668_ net28 net132 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__and2b_1
X_0737_ net150 net43 net29 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__mux2_1
X_0599_ c1.state\[3\] c1.state\[0\] net17 VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__mux2_1
XFILLER_52_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 mem1.trellis_diagr\[18\]\[1\] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_20_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold95 tbck1.sel_bit_out\[2\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 mem1.trellis_diagr\[13\]\[1\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 mem1.trellis_diagr\[16\]\[1\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 mem1.trellis_diagr\[11\]\[0\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 bck_prv_st_10\[1\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1005_ mem1.trellis_diagr\[20\]\[1\] net36 _0551_ mem1.trellis_diagr\[21\]\[1\] _0571_
+ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a221o_1
XFILLER_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
.ends
